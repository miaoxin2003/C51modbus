# Keil uVision project Slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C4051 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: Slave +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 SLAVE.c
